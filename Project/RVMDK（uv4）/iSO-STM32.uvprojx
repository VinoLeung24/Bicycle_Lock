# Keil uVision project iSO-STM32.uvprojx, settings and files
target Led (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 流水灯 +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\Led;..\..\User\delay;..\..\User\IIC;..\..\User\MPU9250;..\..\User\MPU9250\eMPL;..\..\User\sys;..\..\User\TIME;..\..\User\usart;..\..\User\VL53L0X\VL53L0X\myiic;..\..\User\VL53L0X\VL53L0X\vl53l0x;..\..\User\stopwatch;..\..\User\lock
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h
    ../../User/delay/: delay.c
    ../../User/MPU9250/: mpu9250.c
    ../../User/MPU9250/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
    ../../User/Led/: bsp_led.c
    ../../User/TIME/: time.c
    ../../User/usart/: usart.c
    ../../User/sys/: sys.c
    ../../User/IIC/: I2C.c
    ../../User/VL53L0X/VL53L0X/myiic/: myiic.c
    ../../User/VL53L0X/VL53L0X/vl53l0x/: vl53l0x.c
    ../../User/stopwatch/: stopwatch.c
    ../../User/lock/: lock.c
  group DOC
    ../../Doc/: readme.txt
